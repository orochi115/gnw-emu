## qemu-gnw/hw/arm/gnw/Kconfig
```kconfig
config GNW
    bool
    default y
    depends on TCG && ARM
    select ARM_V7M
    select UNIMP
```
